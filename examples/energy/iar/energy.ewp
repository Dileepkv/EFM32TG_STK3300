# IAR project energy.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  ICCARM.CCDefines: EFM32TG840F32; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32TG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: energy.bin
  ILINK.IlinkOutputFile: energy.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32TG840F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32TG/Source/IAR/: startup_efm32tg.s
    ../../../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group Drivers
    ../../../../common/drivers/: vddcheck.c segmentlcd.c
  group BSP
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_rtc.c em_lcd.c em_system.c em_vcmp.c em_usart.c
  group Source
    ../: energy.c
